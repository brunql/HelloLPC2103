# Keil uVision project HelloLPC2103.uvproj, settings and files
target HelloLPC2103 (ARM-ADS)
  device: LPC2103 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: HelloLPC2103 +hex
  c flags: Optim=3 wLevel=2
  c misc: --c99
  c include: .\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x40000000 size 0x2000
  link misc: --entry 0x00000000
  group MainFiles
    ./src/: delay.c main.c Startup.s uart0.c rtc.c
